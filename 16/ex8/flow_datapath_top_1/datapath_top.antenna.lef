

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO datapath_top 
  PIN clk_i 
    ANTENNAPARTIALMETALAREA 1.2494 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2752 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 13.8056 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 33.7795 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.75812 LAYER Via7 ;
  END clk_i
  PIN rst_ni 
    ANTENNAPARTIALMETALAREA 0.2124 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9558 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 20.1436 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 92.2359 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END rst_ni
  PIN operand_a_data_i[31] 
    ANTENNAPARTIALMETALAREA 0.7954 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5478 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 11.9111 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 55.0564 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[31]
  PIN operand_a_data_i[30] 
    ANTENNAPARTIALMETALAREA 0.4114 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8198 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 40.4034 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 185.087 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_a_data_i[30]
  PIN operand_a_data_i[29] 
    ANTENNAPARTIALMETALAREA 0.1874 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8118 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 13.1054 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 60.4513 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[29]
  PIN operand_a_data_i[28] 
    ANTENNAPARTIALMETALAREA 0.8434 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7638 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 11.9385 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 55.1795 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[28]
  PIN operand_a_data_i[27] 
    ANTENNAPARTIALMETALAREA 0.5394 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3958 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 9.34017 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 43.4872 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[27]
  PIN operand_a_data_i[26] 
    ANTENNAPARTIALMETALAREA 0.4684 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1078 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 11.8598 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 55.4974 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_a_data_i[26]
  PIN operand_a_data_i[25] 
    ANTENNAPARTIALMETALAREA 0.4608 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0736 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 23.9521 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 111.056 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_a_data_i[25]
  PIN operand_a_data_i[24] 
    ANTENNAPARTIALMETALAREA 0.1804 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8118 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 22.9265 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 106.441 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_a_data_i[24]
  PIN operand_a_data_i[23] 
    ANTENNAPARTIALMETALAREA 0.6172 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7774 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 28.6154 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 132.041 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_a_data_i[23]
  PIN operand_a_data_i[22] 
    ANTENNAPARTIALMETALAREA 0.5324 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3958 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 9.2057 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 43.2615 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[22]
  PIN operand_a_data_i[21] 
    ANTENNAPARTIALMETALAREA 0.7884 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5478 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 11.5829 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 53.5795 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[21]
  PIN operand_a_data_i[20] 
    ANTENNAPARTIALMETALAREA 0.1692 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7614 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 20.6154 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 96.041 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_a_data_i[20]
  PIN operand_a_data_i[19] 
    ANTENNAPARTIALMETALAREA 0.5964 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6838 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 9.08262 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 42.7077 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[19]
  PIN operand_a_data_i[18] 
    ANTENNAPARTIALMETALAREA 0.8628 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8826 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 11.9453 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 55.5897 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[18]
  PIN operand_a_data_i[17] 
    ANTENNAPARTIALMETALAREA 0.3284 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4778 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 22.5573 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 104.779 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_a_data_i[17]
  PIN operand_a_data_i[16] 
    ANTENNAPARTIALMETALAREA 0.3132 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4094 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 18.7966 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 87.8564 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_a_data_i[16]
  PIN operand_a_data_i[15] 
    ANTENNAPARTIALMETALAREA 0.4892 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2014 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 10.8103 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 49.7641 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[15]
  PIN operand_a_data_i[14] 
    ANTENNAPARTIALMETALAREA 0.1692 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7614 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 13.1829 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 60.8 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[14]
  PIN operand_a_data_i[13] 
    ANTENNAPARTIALMETALAREA 0.5324 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3958 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 11.5123 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 53.6205 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[13]
  PIN operand_a_data_i[12] 
    ANTENNAPARTIALMETALAREA 0.6172 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7774 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 31.241 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 143.856 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_a_data_i[12]
  PIN operand_a_data_i[11] 
    ANTENNAPARTIALMETALAREA 0.3954 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7478 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 36.5282 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 167.61 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_a_data_i[11]
  PIN operand_a_data_i[10] 
    ANTENNAPARTIALMETALAREA 0.5644 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5398 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 18.8615 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 87.0051 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_a_data_i[10]
  PIN operand_a_data_i[9] 
    ANTENNAPARTIALMETALAREA 0.8418 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7566 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 44.3419 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 202.81 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_a_data_i[9]
  PIN operand_a_data_i[8] 
    ANTENNAPARTIALMETALAREA 0.5932 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6694 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 12.5105 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 58.1333 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[8]
  PIN operand_a_data_i[7] 
    ANTENNAPARTIALMETALAREA 0.1804 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8118 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 16.5835 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 76.1026 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[7]
  PIN operand_a_data_i[6] 
    ANTENNAPARTIALMETALAREA 0.5484 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4678 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 14.3453 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 66.0103 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[6]
  PIN operand_a_data_i[5] 
    ANTENNAPARTIALMETALAREA 0.6764 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.0438 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 11.257 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 52.4923 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[5]
  PIN operand_a_data_i[4] 
    ANTENNAPARTIALMETALAREA 0.7612 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4254 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 22.2923 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 101.636 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.844444 LAYER Via7 ;
  END operand_a_data_i[4]
  PIN operand_a_data_i[3] 
    ANTENNAPARTIALMETALAREA 0.8114 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6198 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 15.5419 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 71.7538 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[3]
  PIN operand_a_data_i[2] 
    ANTENNAPARTIALMETALAREA 0.8434 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7638 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 17.7937 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 81.8872 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.85584 LAYER Via7 ;
  END operand_a_data_i[2]
  PIN operand_a_data_i[1] 
    ANTENNAPARTIALMETALAREA 0.4568 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0556 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 35.1658 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 161.518 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_a_data_i[1]
  PIN operand_a_data_i[0] 
    ANTENNAPARTIALMETALAREA 0.2514 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0998 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 29.5778 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 134.749 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.38803 LAYER Via7 ;
  END operand_a_data_i[0]
  PIN operand_b_data_i[31] 
    ANTENNAPARTIALMETALAREA 0.1692 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7614 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 40.6427 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 185.087 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_b_data_i[31]
  PIN operand_b_data_i[30] 
    ANTENNAPARTIALMETALAREA 0.3954 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7478 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 12.5333 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 57.8564 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.75812 LAYER Via7 ;
  END operand_b_data_i[30]
  PIN operand_b_data_i[29] 
    ANTENNAPARTIALMETALAREA 0.2012 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9054 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 13.4154 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 61.959 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_data_i[29]
  PIN operand_b_data_i[28] 
    ANTENNAPARTIALMETALAREA 0.7954 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5478 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 8.01595 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 37.1316 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.562963 LAYER Via7 ;
  END operand_b_data_i[28]
  PIN operand_b_data_i[27] 
    ANTENNAPARTIALMETALAREA 0.2924 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3158 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 35.7154 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 161.969 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_data_i[27]
  PIN operand_b_data_i[26] 
    ANTENNAPARTIALMETALAREA 0.1692 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7614 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 9.37692 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 43.4462 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_data_i[26]
  PIN operand_b_data_i[25] 
    ANTENNAPARTIALMETALAREA 0.3132 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4094 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 23.663 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 107.733 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_data_i[25]
  PIN operand_b_data_i[24] 
    ANTENNAPARTIALMETALAREA 0.4898 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1726 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 9.96581 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 45.7265 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.535043 LAYER Via7 ;
  END operand_b_data_i[24]
  PIN operand_b_data_i[23] 
    ANTENNAPARTIALMETALAREA 0.6162 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7414 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 29.4667 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 133.651 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_data_i[23]
  PIN operand_b_data_i[22] 
    ANTENNAPARTIALMETALAREA 0.4914 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1798 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 38.7419 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 175.928 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_data_i[22]
  PIN operand_b_data_i[21] 
    ANTENNAPARTIALMETALAREA 0.2124 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9558 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 69.559 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 316.287 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_b_data_i[21]
  PIN operand_b_data_i[20] 
    ANTENNAPARTIALMETALAREA 0.6674 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9718 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 16.463 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 75.6923 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_data_i[20]
  PIN operand_b_data_i[19] 
    ANTENNAPARTIALMETALAREA 0.4274 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8918 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 24.9368 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 113.036 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_data_i[19]
  PIN operand_b_data_i[18] 
    ANTENNAPARTIALMETALAREA 1.1474 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1318 LAYER Metal7 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via7 ;
    ANTENNAPARTIALMETALAREA 1.6784 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5816 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 26.2909 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 119.856 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 0.995157 LAYER Via8 ;
  END operand_b_data_i[18]
  PIN operand_b_data_i[17] 
    ANTENNAPARTIALMETALAREA 0.2108 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9486 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 17.1718 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 78.5231 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_data_i[17]
  PIN operand_b_data_i[16] 
    ANTENNAPARTIALMETALAREA 0.399 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.764 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 52.4615 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 237.128 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_data_i[16]
  PIN operand_b_data_i[15] 
    ANTENNAPARTIALMETALAREA 0.7954 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5478 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 36.6066 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 165.621 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_data_i[15]
  PIN operand_b_data_i[14] 
    ANTENNAPARTIALMETALAREA 2.2994 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 10.3158 LAYER Metal7 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via7 ;
    ANTENNAPARTIALMETALAREA 1.3304 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0156 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 100.444 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 461.778 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 5.26543 LAYER Via8 ;
  END operand_b_data_i[14]
  PIN operand_b_data_i[13] 
    ANTENNAPARTIALMETALAREA 0.2924 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3158 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 25.6821 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 117.159 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_data_i[13]
  PIN operand_b_data_i[12] 
    ANTENNAPARTIALMETALAREA 0.2124 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9558 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 8.6849 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 39.9624 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.562963 LAYER Via7 ;
  END operand_b_data_i[12]
  PIN operand_b_data_i[11] 
    ANTENNAPARTIALMETALAREA 0.3314 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4598 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 25.6547 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 117.036 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_data_i[11]
  PIN operand_b_data_i[10] 
    ANTENNAPARTIALMETALAREA 0.7154 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1878 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 40.8308 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 184.79 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_data_i[10]
  PIN operand_b_data_i[9] 
    ANTENNAPARTIALMETALAREA 0.3954 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7478 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 21.9855 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 100.185 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_data_i[9]
  PIN operand_b_data_i[8] 
    ANTENNAPARTIALMETALAREA 0.2172 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9774 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 29.6068 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 135.426 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_b_data_i[8]
  PIN operand_b_data_i[7] 
    ANTENNAPARTIALMETALAREA 0.2178 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9486 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 36.7675 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 168.985 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.63077 LAYER Via7 ;
  END operand_b_data_i[7]
  PIN operand_b_data_i[6] 
    ANTENNAPARTIALMETALAREA 2.149 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 9.639 LAYER Metal7 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via7 ;
    ANTENNAPARTIALMETALAREA 0.6174 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7756 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.92849 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 46.5846 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 0.995157 LAYER Via8 ;
  END operand_b_data_i[6]
  PIN operand_b_data_i[5] 
    ANTENNAPARTIALMETALAREA 0.2924 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3158 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 20.0892 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 91.6513 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_data_i[5]
  PIN operand_b_data_i[4] 
    ANTENNAPARTIALMETALAREA 0.2674 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1718 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 35.4943 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 160.615 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_data_i[4]
  PIN operand_b_data_i[3] 
    ANTENNAPARTIALMETALAREA 0.1804 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8118 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 29.4564 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 134.144 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_data_i[3]
  PIN operand_b_data_i[2] 
    ANTENNAPARTIALMETALAREA 0.7474 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3318 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 23.5521 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 108.113 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_data_i[2]
  PIN operand_b_data_i[1] 
    ANTENNAPARTIALMETALAREA 0.2354 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0278 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 5.5886 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 25.8496 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.562963 LAYER Via7 ;
  END operand_b_data_i[1]
  PIN operand_b_data_i[0] 
    ANTENNAPARTIALMETALAREA 0.1692 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7614 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 44.0821 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 201.641 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END operand_b_data_i[0]
  PIN operand_a_addr_i[7] 
    ANTENNAPARTIALMETALAREA 0.28 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.26 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 273.136 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 1235.33 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 4.66049 LAYER Via7 ;
  END operand_a_addr_i[7]
  PIN operand_a_addr_i[6] 
    ANTENNAPARTIALMETALAREA 0.8578 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8286 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 110.872 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 502.174 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.70427 LAYER Via7 ;
  END operand_a_addr_i[6]
  PIN operand_a_addr_i[5] 
    ANTENNAPARTIALMETALAREA 3.6578 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 16.4286 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 249.012 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 1126.78 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 4.66049 LAYER Via7 ;
  END operand_a_addr_i[5]
  PIN operand_a_addr_i[4] 
    ANTENNAPARTIALMETALAREA 0.4594 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0358 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 131.148 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 594.444 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 4.66049 LAYER Via7 ;
  END operand_a_addr_i[4]
  PIN operand_a_addr_i[3] 
    ANTENNAPARTIALMETALAREA 1.4034 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2838 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 127.198 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 576.667 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 4.66049 LAYER Via7 ;
  END operand_a_addr_i[3]
  PIN operand_a_addr_i[2] 
    ANTENNAPARTIALMETALAREA 1.193 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 5.337 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 130.523 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 592.759 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.70427 LAYER Via7 ;
  END operand_a_addr_i[2]
  PIN operand_a_addr_i[1] 
    ANTENNAPARTIALMETALAREA 0.7612 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4254 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 145.457 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 664.667 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 4.05556 LAYER Via7 ;
  END operand_a_addr_i[1]
  PIN operand_a_addr_i[0] 
    ANTENNAPARTIALMETALAREA 1.0034 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4838 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 169.614 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 769.621 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 3.21026 LAYER Via7 ;
  END operand_a_addr_i[0]
  PIN operand_b_addr_i[7] 
    ANTENNAPARTIALMETALAREA 0.1804 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8118 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 10.4618 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 48.3282 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_addr_i[7]
  PIN operand_b_addr_i[6] 
    ANTENNAPARTIALMETALAREA 0.3656 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6452 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 7.75185 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 36.4923 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_addr_i[6]
  PIN operand_b_addr_i[5] 
    ANTENNAPARTIALMETALAREA 1.5404 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9318 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 19.5536 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 89.6 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_addr_i[5]
  PIN operand_b_addr_i[4] 
    ANTENNAPARTIALMETALAREA 0.6658 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9646 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 5.36296 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 25.1932 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.562963 LAYER Via7 ;
  END operand_b_addr_i[4]
  PIN operand_b_addr_i[3] 
    ANTENNAPARTIALMETALAREA 0.6492 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9214 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 19.6242 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 89.559 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_addr_i[3]
  PIN operand_b_addr_i[2] 
    ANTENNAPARTIALMETALAREA 1.3234 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9238 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 26.0684 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 119.436 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_addr_i[2]
  PIN operand_b_addr_i[1] 
    ANTENNAPARTIALMETALAREA 0.7634 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4038 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 17.7265 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 81.8974 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END operand_b_addr_i[1]
  PIN operand_b_addr_i[0] 
    ANTENNAPARTIALMETALAREA 1.3324 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9958 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 19.3028 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 88.4718 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.883476 LAYER Via7 ;
  END operand_b_addr_i[0]
  PIN operand_a_offset_i[31] 
  END operand_a_offset_i[31]
  PIN operand_a_offset_i[30] 
  END operand_a_offset_i[30]
  PIN operand_a_offset_i[29] 
  END operand_a_offset_i[29]
  PIN operand_a_offset_i[28] 
  END operand_a_offset_i[28]
  PIN operand_a_offset_i[27] 
  END operand_a_offset_i[27]
  PIN operand_a_offset_i[26] 
  END operand_a_offset_i[26]
  PIN operand_a_offset_i[25] 
  END operand_a_offset_i[25]
  PIN operand_a_offset_i[24] 
  END operand_a_offset_i[24]
  PIN operand_a_offset_i[23] 
  END operand_a_offset_i[23]
  PIN operand_a_offset_i[22] 
  END operand_a_offset_i[22]
  PIN operand_a_offset_i[21] 
  END operand_a_offset_i[21]
  PIN operand_a_offset_i[20] 
  END operand_a_offset_i[20]
  PIN operand_a_offset_i[19] 
  END operand_a_offset_i[19]
  PIN operand_a_offset_i[18] 
  END operand_a_offset_i[18]
  PIN operand_a_offset_i[17] 
  END operand_a_offset_i[17]
  PIN operand_a_offset_i[16] 
  END operand_a_offset_i[16]
  PIN operand_a_offset_i[15] 
  END operand_a_offset_i[15]
  PIN operand_a_offset_i[14] 
  END operand_a_offset_i[14]
  PIN operand_a_offset_i[13] 
  END operand_a_offset_i[13]
  PIN operand_a_offset_i[12] 
  END operand_a_offset_i[12]
  PIN operand_a_offset_i[11] 
  END operand_a_offset_i[11]
  PIN operand_a_offset_i[10] 
  END operand_a_offset_i[10]
  PIN operand_a_offset_i[9] 
  END operand_a_offset_i[9]
  PIN operand_a_offset_i[8] 
  END operand_a_offset_i[8]
  PIN operand_a_offset_i[7] 
  END operand_a_offset_i[7]
  PIN operand_a_offset_i[6] 
  END operand_a_offset_i[6]
  PIN operand_a_offset_i[5] 
  END operand_a_offset_i[5]
  PIN operand_a_offset_i[4] 
  END operand_a_offset_i[4]
  PIN operand_a_offset_i[3] 
  END operand_a_offset_i[3]
  PIN operand_a_offset_i[2] 
  END operand_a_offset_i[2]
  PIN operand_a_offset_i[1] 
  END operand_a_offset_i[1]
  PIN operand_a_offset_i[0] 
  END operand_a_offset_i[0]
  PIN operand_b_offset_i[31] 
  END operand_b_offset_i[31]
  PIN operand_b_offset_i[30] 
  END operand_b_offset_i[30]
  PIN operand_b_offset_i[29] 
  END operand_b_offset_i[29]
  PIN operand_b_offset_i[28] 
  END operand_b_offset_i[28]
  PIN operand_b_offset_i[27] 
  END operand_b_offset_i[27]
  PIN operand_b_offset_i[26] 
  END operand_b_offset_i[26]
  PIN operand_b_offset_i[25] 
  END operand_b_offset_i[25]
  PIN operand_b_offset_i[24] 
  END operand_b_offset_i[24]
  PIN operand_b_offset_i[23] 
  END operand_b_offset_i[23]
  PIN operand_b_offset_i[22] 
  END operand_b_offset_i[22]
  PIN operand_b_offset_i[21] 
  END operand_b_offset_i[21]
  PIN operand_b_offset_i[20] 
  END operand_b_offset_i[20]
  PIN operand_b_offset_i[19] 
  END operand_b_offset_i[19]
  PIN operand_b_offset_i[18] 
  END operand_b_offset_i[18]
  PIN operand_b_offset_i[17] 
  END operand_b_offset_i[17]
  PIN operand_b_offset_i[16] 
  END operand_b_offset_i[16]
  PIN operand_b_offset_i[15] 
  END operand_b_offset_i[15]
  PIN operand_b_offset_i[14] 
  END operand_b_offset_i[14]
  PIN operand_b_offset_i[13] 
  END operand_b_offset_i[13]
  PIN operand_b_offset_i[12] 
  END operand_b_offset_i[12]
  PIN operand_b_offset_i[11] 
  END operand_b_offset_i[11]
  PIN operand_b_offset_i[10] 
  END operand_b_offset_i[10]
  PIN operand_b_offset_i[9] 
  END operand_b_offset_i[9]
  PIN operand_b_offset_i[8] 
  END operand_b_offset_i[8]
  PIN operand_b_offset_i[7] 
  END operand_b_offset_i[7]
  PIN operand_b_offset_i[6] 
  END operand_b_offset_i[6]
  PIN operand_b_offset_i[5] 
  END operand_b_offset_i[5]
  PIN operand_b_offset_i[4] 
  END operand_b_offset_i[4]
  PIN operand_b_offset_i[3] 
  END operand_b_offset_i[3]
  PIN operand_b_offset_i[2] 
  END operand_b_offset_i[2]
  PIN operand_b_offset_i[1] 
  END operand_b_offset_i[1]
  PIN operand_b_offset_i[0] 
  END operand_b_offset_i[0]
  PIN re_a_i 
    ANTENNAPARTIALMETALAREA 1.0172 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5774 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 49.6752 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 226.81 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.84786 LAYER Via7 ;
  END re_a_i
  PIN re_b_i 
    ANTENNAPARTIALMETALAREA 1.1708 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2686 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 11.6667 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 54.2256 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.75812 LAYER Via7 ;
  END re_b_i
  PIN we_a_i 
    ANTENNAPARTIALMETALAREA 1.2274 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4918 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 29.8154 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 136.297 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 1.43419 LAYER Via7 ;
  END we_a_i
  PIN we_b_i 
    ANTENNAPARTIALMETALAREA 0.6194 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7558 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 5.44501 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 25.5624 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.562963 LAYER Via7 ;
  END we_b_i
  PIN result_o[63] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.3872 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7424 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.47855 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 52.2111 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[63]
  PIN result_o[62] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.0584 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7628 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.04526 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 59.2613 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[62]
  PIN result_o[61] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.764 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 3.438 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.28679 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 55.8481 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[61]
  PIN result_o[60] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.4904 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2068 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.73423 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 53.3616 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[60]
  PIN result_o[59] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.8856 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9852 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.76752 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 58.3421 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[59]
  PIN result_o[58] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.5968 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6856 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.0311 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 54.6976 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[58]
  PIN result_o[57] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.4328 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4476 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.89436 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 63.4128 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[57]
  PIN result_o[56] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.5544 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9948 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.47316 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 61.5174 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[56]
  PIN result_o[55] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.3232 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4544 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.87666 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 54.0026 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[55]
  PIN result_o[54] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.2516 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6322 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.11829 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 59.9205 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[54]
  PIN result_o[53] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.4904 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2068 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.90583 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 54.1338 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[53]
  PIN result_o[52] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.0264 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6188 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.73166 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 57.9176 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[52]
  PIN result_o[51] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.7528 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3876 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.61454 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 57.323 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[51]
  PIN result_o[50] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.46 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.50496 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 57.1605 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[50]
  PIN result_o[49] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.3232 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4544 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.80802 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 53.6937 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[49]
  PIN result_o[48] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.2808 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7636 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.66188 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 62.3667 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[48]
  PIN result_o[47] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.7726 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4452 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.13949 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 55.4621 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[47]
  PIN result_o[46] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.8912 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0104 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.77413 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 58.0412 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[46]
  PIN result_o[45] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.0264 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6188 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.83934 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 58.3346 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[45]
  PIN result_o[44] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.4176 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3792 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 10.1933 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 64.4273 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[44]
  PIN result_o[43] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.5856 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6352 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.06542 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 54.852 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[43]
  PIN result_o[42] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.3232 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4544 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.43393 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 52.0103 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[42]
  PIN result_o[41] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.612 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.754 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.02632 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 55.0067 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[41]
  PIN result_o[40] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.8136 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6612 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.68662 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 57.6474 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[40]
  PIN result_o[39] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.1782 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.71021 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 57.686 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[39]
  PIN result_o[38] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.1852 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3334 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.2906 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 60.6959 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[38]
  PIN result_o[37] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.5968 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6856 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.13573 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 55.499 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[37]
  PIN result_o[36] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.923 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 4.122 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 10.5398 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 66.3174 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[36]
  PIN result_o[35] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.3232 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4544 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.46825 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 52.1647 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[35]
  PIN result_o[34] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.0072 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5324 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.61983 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 57.6774 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[34]
  PIN result_o[33] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.1782 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.16323 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 55.2921 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[33]
  PIN result_o[32] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.4792 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1564 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.90583 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 54.1338 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[32]
  PIN result_o[31] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.3872 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7424 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.46825 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 52.1647 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[31]
  PIN result_o[30] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.3552 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5984 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.84234 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 53.8481 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[30]
  PIN result_o[29] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.2016 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9072 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.53333 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 61.7882 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[29]
  PIN result_o[28] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.619 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.754 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.32 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 60.8282 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[28]
  PIN result_o[27] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.7336 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3012 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.98803 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 54.8344 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[27]
  PIN result_o[26] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.1712 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.80502 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 58.1802 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[26]
  PIN result_o[25] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.315 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.386 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.69538 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 53.5174 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[25]
  PIN result_o[24] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.1782 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.50769 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 57.1728 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[24]
  PIN result_o[23] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.0984 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9428 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.90701 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 58.9697 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[23]
  PIN result_o[22] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.5452 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4534 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.74882 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 53.4273 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[22]
  PIN result_o[21] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.4366 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9332 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.29538 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 56.1636 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[21]
  PIN result_o[20] 
    ANTENNADIFFAREA 3.12228 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.4366 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9332 LAYER Metal8 ;
  END result_o[20]
  PIN result_o[19] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.5544 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9948 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.88342 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 63.3636 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[19]
  PIN result_o[18] 
    ANTENNADIFFAREA 3.12228 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.2512 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1304 LAYER Metal8 ;
  END result_o[18]
  PIN result_o[17] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.923 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 4.122 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.01641 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 59.4621 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[17]
  PIN result_o[16] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.9048 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0716 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.70188 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 58.0467 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[16]
  PIN result_o[15] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.8654 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8628 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 10.5768 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 66.4836 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[15]
  PIN result_o[14] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.4686 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0772 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.96075 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 54.381 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[14]
  PIN result_o[13] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.3392 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5264 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.25761 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 51.2844 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[13]
  PIN result_o[12] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.4032 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8144 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.39318 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 56.3269 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[12]
  PIN result_o[11] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.5126 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2752 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.58017 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 57.499 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[11]
  PIN result_o[10] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.3272 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4724 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.43658 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 56.8528 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[10]
  PIN result_o[9] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.1712 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.27263 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 51.2844 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[9]
  PIN result_o[8] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.1712 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 7.96068 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 54.7113 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[8]
  PIN result_o[7] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.2968 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3356 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 10.1432 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 64.5328 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[7]
  PIN result_o[6] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.7308 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2886 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.63966 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 57.7667 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[6]
  PIN result_o[5] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.1662 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2164 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.82735 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 58.5574 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[5]
  PIN result_o[4] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.1782 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.79214 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 58.4528 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[4]
  PIN result_o[3] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.999 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 4.464 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.08581 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 59.7205 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[3]
  PIN result_o[2] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.2808 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7636 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.95077 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 59.1667 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[2]
  PIN result_o[1] 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.1782 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.90974 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 58.9821 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END result_o[1]
  PIN result_o[0] 
    ANTENNADIFFAREA 3.1578 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 0.4032 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8144 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 8.0843 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 54.9369 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.31961 LAYER Via8 ;
  END result_o[0]
  PIN scan_mode_datapath_top 
    ANTENNAPARTIALMETALAREA 0.5438 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4156 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 6.55043 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 30.5368 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 0.562963 LAYER Via7 ;
  END scan_mode_datapath_top
  PIN scan_enable_datapath_top 
    ANTENNAPARTIALMETALAREA 0.9956 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4802 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 40.7829 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 188.185 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.75556 LAYER Via7 ;
  END scan_enable_datapath_top
  PIN scan_in_datapath_top_0 
    ANTENNAPARTIALMETALAREA 0.1874 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8118 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 86.4393 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 392.636 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 3.97778 LAYER Via7 ;
  END scan_in_datapath_top_0
  PIN scan_out_datapath_top_0 
    ANTENNADIFFAREA 3.839 LAYER Metal8 ; 
    ANTENNAPARTIALMETALAREA 1.636 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 7.362 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 9.61983 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 62.2313 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 6.50462 LAYER Via8 ;
  END scan_out_datapath_top_0
END datapath_top

END LIBRARY
