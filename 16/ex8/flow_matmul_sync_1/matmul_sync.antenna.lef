

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO matmul_sync 
  PIN clk_i 
    ANTENNAPARTIALMETALAREA 0.99075 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5514 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 6.54359 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 25.1726 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.451282 LAYER Via5 ;
  END clk_i
  PIN rst_ni 
    ANTENNAPARTIALMETALAREA 0.3474 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5318 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 27.3673 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 129.926 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.60802 LAYER Via5 ;
  END rst_ni
  PIN operand_a_i[31] 
    ANTENNAPARTIALMETALAREA 1.433 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.417 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 71.5282 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 326.482 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[31]
  PIN operand_a_i[30] 
    ANTENNAPARTIALMETALAREA 0.9234 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1238 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 39.8085 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 184.821 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[30]
  PIN operand_a_i[29] 
    ANTENNAPARTIALMETALAREA 1.5314 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.8598 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 61.135 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 279.713 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[29]
  PIN operand_a_i[28] 
    ANTENNAPARTIALMETALAREA 0.9874 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4118 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 41.4769 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 192.328 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[28]
  PIN operand_a_i[27] 
    ANTENNAPARTIALMETALAREA 1.6274 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.2918 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 72.9949 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 331.056 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.98462 LAYER Via5 ;
  END operand_a_i[27]
  PIN operand_a_i[26] 
    ANTENNAPARTIALMETALAREA 1.7164 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.7238 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 64.2872 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 294.974 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[26]
  PIN operand_a_i[25] 
    ANTENNAPARTIALMETALAREA 0.8364 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7638 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 34.1744 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 160.328 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.70769 LAYER Via5 ;
  END operand_a_i[25]
  PIN operand_a_i[24] 
    ANTENNAPARTIALMETALAREA 0.9554 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2678 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 39.3436 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 182.728 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[24]
  PIN operand_a_i[23] 
    ANTENNAPARTIALMETALAREA 0.7932 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5694 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 47.8974 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 220.144 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.73162 LAYER Via5 ;
  END operand_a_i[23]
  PIN operand_a_i[22] 
    ANTENNAPARTIALMETALAREA 1.7386 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.7922 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 69.2376 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 317.251 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[22]
  PIN operand_a_i[21] 
    ANTENNAPARTIALMETALAREA 1.4034 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2838 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 69.9145 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 319.221 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[21]
  PIN operand_a_i[20] 
    ANTENNAPARTIALMETALAREA 1.8602 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.3394 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 68.0615 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 311.959 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[20]
  PIN operand_a_i[19] 
    ANTENNAPARTIALMETALAREA 1.5434 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9138 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 72.5128 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 330.913 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[19]
  PIN operand_a_i[18] 
    ANTENNAPARTIALMETALAREA 1.4026 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2802 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 70.4342 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 321.559 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[18]
  PIN operand_a_i[17] 
    ANTENNAPARTIALMETALAREA 0.8594 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8358 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 49.9692 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 231.405 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.54017 LAYER Via5 ;
  END operand_a_i[17]
  PIN operand_a_i[16] 
    ANTENNAPARTIALMETALAREA 0.1874 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8118 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 39.8291 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 183.836 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[16]
  PIN operand_a_i[15] 
    ANTENNAPARTIALMETALAREA 0.8684 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9078 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 50.5573 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 233.19 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[15]
  PIN operand_a_i[14] 
    ANTENNAPARTIALMETALAREA 1.4826 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6402 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 92.5607 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 421.128 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[14]
  PIN operand_a_i[13] 
    ANTENNAPARTIALMETALAREA 1.5618 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9966 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 85.9692 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 391.467 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[13]
  PIN operand_a_i[12] 
    ANTENNAPARTIALMETALAREA 0.2354 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0278 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 51.9179 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 238.236 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[12]
  PIN operand_a_i[11] 
    ANTENNAPARTIALMETALAREA 0.8274 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6918 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 50.7692 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 233.067 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[11]
  PIN operand_a_i[10] 
    ANTENNAPARTIALMETALAREA 0.8892 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0014 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 38.9949 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 180.082 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.73162 LAYER Via5 ;
  END operand_a_i[10]
  PIN operand_a_i[9] 
    ANTENNAPARTIALMETALAREA 1.3714 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1398 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 59.6581 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 273.067 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[9]
  PIN operand_a_i[8] 
    ANTENNAPARTIALMETALAREA 1.9116 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.6022 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 71.7744 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 327.59 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[8]
  PIN operand_a_i[7] 
    ANTENNAPARTIALMETALAREA 2.3154 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 10.3878 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 91.0359 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 415.344 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[7]
  PIN operand_a_i[6] 
    ANTENNAPARTIALMETALAREA 2.2034 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8838 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 96.7453 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 439.959 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[6]
  PIN operand_a_i[5] 
    ANTENNAPARTIALMETALAREA 1.5634 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.0038 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 80.9709 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 370.051 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[5]
  PIN operand_a_i[4] 
    ANTENNAPARTIALMETALAREA 2.1066 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.4482 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 85.641 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 389.99 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[4]
  PIN operand_a_i[3] 
    ANTENNAPARTIALMETALAREA 2.0242 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0774 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 79.2308 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 359.118 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.98462 LAYER Via5 ;
  END operand_a_i[3]
  PIN operand_a_i[2] 
    ANTENNAPARTIALMETALAREA 2.0242 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0774 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 77.135 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 351.713 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[2]
  PIN operand_a_i[1] 
    ANTENNAPARTIALMETALAREA 1.4756 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6402 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 55.0291 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 254.174 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.54017 LAYER Via5 ;
  END operand_a_i[1]
  PIN operand_a_i[0] 
    ANTENNAPARTIALMETALAREA 0.1874 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8118 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 41.388 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 190.851 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_a_i[0]
  PIN operand_b_i[31] 
    ANTENNAPARTIALMETALAREA 0.9874 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4118 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 92.6154 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 421.374 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[31]
  PIN operand_b_i[30] 
    ANTENNAPARTIALMETALAREA 0.9074 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0518 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 39.6444 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 184.082 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[30]
  PIN operand_b_i[29] 
    ANTENNAPARTIALMETALAREA 0.2354 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0278 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 45.0256 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 207.221 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[29]
  PIN operand_b_i[28] 
    ANTENNAPARTIALMETALAREA 1.5778 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.0686 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 98.5846 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 449.313 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[28]
  PIN operand_b_i[27] 
    ANTENNAPARTIALMETALAREA 1.6266 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.2882 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 64.0615 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 292.882 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[27]
  PIN operand_b_i[26] 
    ANTENNAPARTIALMETALAREA 1.9932 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.9694 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 88.4718 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 402.728 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.73162 LAYER Via5 ;
  END operand_b_i[26]
  PIN operand_b_i[25] 
    ANTENNAPARTIALMETALAREA 1.6754 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5078 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 62.9197 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 288.821 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[25]
  PIN operand_b_i[24] 
    ANTENNAPARTIALMETALAREA 1.6754 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5078 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 64.9983 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 298.174 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[24]
  PIN operand_b_i[23] 
    ANTENNAPARTIALMETALAREA 0.6994 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1158 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 72.5675 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 331.159 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[23]
  PIN operand_b_i[22] 
    ANTENNAPARTIALMETALAREA 1.721 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.713 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 64.4786 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 295.836 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[22]
  PIN operand_b_i[21] 
    ANTENNAPARTIALMETALAREA 1.6898 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5726 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 66.0103 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 302.728 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[21]
  PIN operand_b_i[20] 
    ANTENNAPARTIALMETALAREA 0.9394 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1958 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 57.8872 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 266.174 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[20]
  PIN operand_b_i[19] 
    ANTENNAPARTIALMETALAREA 1.3874 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2118 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 66.1128 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 302.113 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[19]
  PIN operand_b_i[18] 
    ANTENNAPARTIALMETALAREA 1.6266 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.2882 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 72.0821 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 330.051 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[18]
  PIN operand_b_i[17] 
    ANTENNAPARTIALMETALAREA 0.9386 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1922 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 37.7231 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 174.359 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[17]
  PIN operand_b_i[16] 
    ANTENNAPARTIALMETALAREA 0.1692 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7614 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 45.5179 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 209.436 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.73162 LAYER Via5 ;
  END operand_b_i[16]
  PIN operand_b_i[15] 
    ANTENNAPARTIALMETALAREA 0.7474 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3318 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 93.094 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 424.39 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.54017 LAYER Via5 ;
  END operand_b_i[15]
  PIN operand_b_i[14] 
    ANTENNAPARTIALMETALAREA 0.7954 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5478 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 162.963 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 745.148 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.58642 LAYER Via5 ;
  END operand_b_i[14]
  PIN operand_b_i[13] 
    ANTENNAPARTIALMETALAREA 1.4674 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.5718 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 103.501 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 470.359 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[13]
  PIN operand_b_i[12] 
    ANTENNAPARTIALMETALAREA 0.5476 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4642 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 121.185 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 557.148 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.58642 LAYER Via5 ;
  END operand_b_i[12]
  PIN operand_b_i[11] 
    ANTENNAPARTIALMETALAREA 0.9074 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0518 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 76.3692 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 348.267 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[11]
  PIN operand_b_i[10] 
    ANTENNAPARTIALMETALAREA 0.9714 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3398 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 76.4786 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 348.759 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[10]
  PIN operand_b_i[9] 
    ANTENNAPARTIALMETALAREA 1.0506 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6962 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 78.2291 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 356.636 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[9]
  PIN operand_b_i[8] 
    ANTENNAPARTIALMETALAREA 1.0034 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4838 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 68.7385 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 313.928 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[8]
  PIN operand_b_i[7] 
    ANTENNAPARTIALMETALAREA 1.3874 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2118 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 57.641 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 263.897 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.03419 LAYER Via5 ;
  END operand_b_i[7]
  PIN operand_b_i[6] 
    ANTENNAPARTIALMETALAREA 0.6116 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7522 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 46.716 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 222.037 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.58642 LAYER Via5 ;
  END operand_b_i[6]
  PIN operand_b_i[5] 
    ANTENNAPARTIALMETALAREA 0.9644 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3398 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 44.9504 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 207.959 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[5]
  PIN operand_b_i[4] 
    ANTENNAPARTIALMETALAREA 0.5204 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3418 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 39.4568 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 189.37 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.58642 LAYER Via5 ;
  END operand_b_i[4]
  PIN operand_b_i[3] 
    ANTENNAPARTIALMETALAREA 1.0026 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4802 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 38.7419 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 180.021 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[3]
  PIN operand_b_i[2] 
    ANTENNAPARTIALMETALAREA 0.8684 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9078 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 36.9915 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 172.144 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[2]
  PIN operand_b_i[1] 
    ANTENNAPARTIALMETALAREA 0.1692 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7614 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 39.788 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 184.513 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.54017 LAYER Via5 ;
  END operand_b_i[1]
  PIN operand_b_i[0] 
    ANTENNAPARTIALMETALAREA 0.9074 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0518 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 41.8598 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 194.051 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.89915 LAYER Via5 ;
  END operand_b_i[0]
  PIN result_o[63] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3424 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5408 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.1568 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 55.2072 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[63]
  PIN result_o[62] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3606 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5912 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.57808 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 52.5354 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[62]
  PIN result_o[61] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.7028 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1626 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.18855 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 55.3501 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[61]
  PIN result_o[60] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.4184 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8828 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.61626 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 52.7748 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[60]
  PIN result_o[59] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.8896 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0032 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.60982 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 57.2458 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[59]
  PIN result_o[58] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.6432 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8944 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.80202 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 53.6782 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[58]
  PIN result_o[57] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3424 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5408 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.67632 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 53.045 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[57]
  PIN result_o[56] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.7224 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2508 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.2958 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 55.8327 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[56]
  PIN result_o[55] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 1.2696 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7132 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 9.63085 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 61.8404 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[55]
  PIN result_o[54] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.4032 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8144 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.95946 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 54.3192 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[54]
  PIN result_o[53] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3424 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5408 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.642 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 52.8906 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[53]
  PIN result_o[52] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.8896 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0032 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.78142 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 58.018 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[52]
  PIN result_o[51] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.5552 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4984 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.47941 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 56.6589 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[51]
  PIN result_o[50] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.4184 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8828 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.91484 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 54.1184 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[50]
  PIN result_o[49] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.8364 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7638 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.36873 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 56.1609 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[49]
  PIN result_o[48] 
    ANTENNADIFFAREA 3.12228 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.1782 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal6 ;
  END result_o[48]
  PIN result_o[47] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.6494 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8908 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 11.3897 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 69.7555 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[47]
  PIN result_o[46] 
    ANTENNADIFFAREA 3.839 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.467 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 10.9285 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 68.0221 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.47111 LAYER Via6 ;
  END result_o[46]
  PIN result_o[45] 
    ANTENNADIFFAREA 3.839 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.6708 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.0186 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.66872 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 57.8528 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.47111 LAYER Via6 ;
  END result_o[45]
  PIN result_o[44] 
    ANTENNADIFFAREA 3.839 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.4974 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2068 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.78838 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 58.3913 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.47111 LAYER Via6 ;
  END result_o[44]
  PIN result_o[43] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.7254 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2328 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 9.80245 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 62.6126 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[43]
  PIN result_o[42] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3424 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5408 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.77928 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 53.5084 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[42]
  PIN result_o[41] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.4488 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0196 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.76727 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 53.4543 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[41]
  PIN result_o[40] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.616 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.772 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.19455 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 55.3771 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[40]
  PIN result_o[39] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.46 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.49271 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 52.2188 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[39]
  PIN result_o[38] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3424 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5408 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.67632 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 53.045 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[38]
  PIN result_o[37] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.6272 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8224 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.95431 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 54.296 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[37]
  PIN result_o[36] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3536 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5912 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.2988 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 51.3462 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[36]
  PIN result_o[35] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.6272 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8224 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.36615 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 56.1493 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[35]
  PIN result_o[34] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.9328 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1976 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.7471 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 57.8636 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[34]
  PIN result_o[33] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.8044 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.6198 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.19713 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 55.3887 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[33]
  PIN result_o[32] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.4488 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0196 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.83591 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 53.7632 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[32]
  PIN result_o[31] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3536 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5912 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.33312 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 51.5006 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[31]
  PIN result_o[30] 
    ANTENNADIFFAREA 3.839 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 2.7856 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 12.5352 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 11.9597 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 72.6621 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.47111 LAYER Via6 ;
  END result_o[30]
  PIN result_o[29] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.5148 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3166 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.71321 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 53.2111 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[29]
  PIN result_o[28] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.9008 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0536 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.33054 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 56.0566 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[28]
  PIN result_o[27] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.6432 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8944 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.77799 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 53.5701 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[27]
  PIN result_o[26] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3536 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5912 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.40176 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 51.8095 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[26]
  PIN result_o[25] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.7336 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3012 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.18254 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 55.323 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[25]
  PIN result_o[24] 
    ANTENNADIFFAREA 3.839 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.4822 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1384 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.585 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 9.68137 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 62.4097 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.47111 LAYER Via6 ;
  END result_o[24]
  PIN result_o[23] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.8288 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.7296 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 9.75268 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 62.3887 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[23]
  PIN result_o[22] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3536 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5912 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.33312 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 51.5006 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[22]
  PIN result_o[21] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 1.0142 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5324 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 9.11733 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 59.462 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[21]
  PIN result_o[20] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.8896 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0032 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.81574 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 58.1725 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[20]
  PIN result_o[19] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.4488 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0196 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.59095 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 57.1609 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[19]
  PIN result_o[18] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.1782 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.15294 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 55.1223 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[18]
  PIN result_o[17] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.7508 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3786 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.75826 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 57.9138 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[17]
  PIN result_o[16] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.7224 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2508 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.8003 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 58.103 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[16]
  PIN result_o[15] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3424 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5408 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.77928 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 53.5084 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[15]
  PIN result_o[14] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.616 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.772 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.22887 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 55.5315 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[14]
  PIN result_o[13] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.4084 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8378 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.48498 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 52.184 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[13]
  PIN result_o[12] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.46 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.61969 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 52.7902 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[12]
  PIN result_o[11] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3536 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5912 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 7.43608 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 51.964 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[11]
  PIN result_o[10] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.1782 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.13621 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 55.1145 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[10]
  PIN result_o[9] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.4032 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8144 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.49828 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 56.7439 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[9]
  PIN result_o[8] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.3536 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5912 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.43136 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 56.4427 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[8]
  PIN result_o[7] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.46 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 9.58623 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 61.6396 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[7]
  PIN result_o[6] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 1.1744 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2848 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 10.5009 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 65.7555 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[6]
  PIN result_o[5] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.1712 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7704 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.73681 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 57.8172 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[5]
  PIN result_o[4] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.7336 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3012 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.62527 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 57.3153 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[4]
  PIN result_o[3] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 1.224 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 5.508 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 9.61712 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 61.7786 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[3]
  PIN result_o[2] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.6662 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9664 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 8.30223 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 55.7941 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[2]
  PIN result_o[1] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 1.2788 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7546 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 9.80159 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 62.6088 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[1]
  PIN result_o[0] 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.996 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.482 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 9.76469 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 62.4427 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END result_o[0]
  PIN scan_mode_matmul_sync 
  END scan_mode_matmul_sync
  PIN scan_enable_matmul_sync 
    ANTENNAPARTIALMETALAREA 1.0124 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5558 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.15255 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 12.008 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 64.1924 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.16632 LAYER Via5 ;
  END scan_enable_matmul_sync
  PIN scan_in_matmul_sync_0 
    ANTENNAPARTIALMETALAREA 0.9956 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4802 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 38.906 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 177.99 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.51453 LAYER Via5 ;
  END scan_in_matmul_sync_0
  PIN scan_out_matmul_sync_0 
    ANTENNADIFFAREA 3.1578 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.7528 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3876 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.4662 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 10.9762 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 67.8945 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.27756 LAYER Via6 ;
  END scan_out_matmul_sync_0
END matmul_sync

END LIBRARY
